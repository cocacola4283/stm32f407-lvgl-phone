# Keil uVision project stm32f407_lvgl.uvprojx, settings and files
target stm32f407vet6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\User;..\..\Drivers\BSP;..\..\Drivers\BSP\LCD;..\..\Drivers\SYSTEM\sys;..\..\Middlewares\LVGL\LVGL_SRC\lvgl;..\..\Middlewares\LVGL\LVGL_SRC\lvgl\examples\porting;..\..\Middlewares\LVGL\LVGL_SRC;..\..\GUI\generated;..\..\GUI\generated\assets\fonts;..\..\GUI\generated\assets\images;..\..\GUI\generated\events;..\..\GUI\generated\screens;..\..\GUI\custom;..\..\GUI\game2048;..\..\GUI\apps
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LCD/: lcd.c lcdfont.h lcd.h
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c tp_cal.c tp_cal.h
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/TIMER/: btim.c
  group Drivers/BSP/SD
    ../../Drivers/BSP/SD/: sd_card.c sd_card.h fat_ro.c fat_ro.h
  group GUI/generated
    ../../GUI/generated/: gg_utils.c
  group GUI/generated/assets/fonts
    ../../GUI/generated/assets/fonts/: lv_font_Alatsi_13.c lv_font_Alatsi_15.c lv_font_Alatsi_17.c lv_font_Alatsi_27.c lv_font_Alatsi_40.c lv_font_FontAwesome7_20.c
  group GUI/generated/events
    ../../GUI/generated/events/: gg_event_Game2048.c gg_event_layer_bottom.c gg_event_layer_sys.c gg_event_layer_top.c
  group GUI/generated/screens
    ../../GUI/generated/screens/: gg_Game2048.c gg_layer_bottom.c gg_layer_sys.c gg_layer_top.c
  group GUI/game2048
    ../../GUI/game2048/: gui_2048.c gui_2048.h
  group GUI/apps
    ../../GUI/apps/: app_shell.c app_shell.h app_files.c app_files.h
  group GUI/custom
    ../../GUI/custom/: custom.c
  group Readme
    ../../: readme.txt
  group Mid/lvgl/conf
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/: lvgl.h lv_conf.h lvgl_private.h lv_version.h
  group Mid/lvgl/src
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/: lv_init.c
  group Mid/lvgl/example/porting
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group Mid/lvgl/src/core
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
  group Mid/lvgl/src/display
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/display/: lv_display.c
  group Mid/lvgl/src/indev
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group Mid/lvgl/src/tick
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/tick/: lv_tick.c
  group Mid/lvgl/src/osal
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/osal/: lv_os.c lv_os_none.c
  group Mid/lvgl/src/stdlib
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/stdlib/: lv_mem.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group Mid/lvgl/src/misc
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group Mid/lvgl/src/draw
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group Mid/lvgl/src/draw/convert
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/convert/: lv_draw_buf_convert.c
  group Mid/lvgl/src/draw/sw
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group Mid/lvgl/src/font
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/font/imgfont/: lv_imgfont.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Mid/lvgl/src/widgets
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/arc/: lv_arc.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/bar/: lv_bar.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/button/: lv_button.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/gif/: lv_gif.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/image/: lv_image.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/label/: lv_label.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/line/: lv_line.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/roller/: lv_roller.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/scale/: lv_scale.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/slider/: lv_slider.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/switch/: lv_switch.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/table/: lv_table.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/win/: lv_win.c
  group Mid/lvgl/src/themes
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/themes/default/: lv_theme_default.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/themes/: lv_theme.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/themes/simple/: lv_theme_simple.c
  group Mid/lvgl/src/layouts
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/layouts/grid/: lv_grid.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/layouts/: lv_layout.c
  group Mid/lvgl/src/debugging
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/debugging/sysmon/: lv_sysmon.c
  group Mid/lvgl/src/libs/bin_decoder
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
